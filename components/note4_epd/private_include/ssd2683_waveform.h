#ifndef SSD2683_WAVEFORM_H_
#define SSD2683_WAVEFORM_H_

#include "note4_epd_calibration.h"
#include <array>
#include <cstddef>
#include <cstdint>

namespace ssd2683_waveform {

constexpr size_t kWaveformSize = 535;
constexpr size_t kAnalogConfigSize = 7;
constexpr size_t kTableCount = 6;
constexpr size_t kTableSize = 88;
constexpr size_t kRecordsPerTable = 8;
constexpr size_t kRecordSize = 11;
constexpr size_t kVendorGray16RenderPassCount = 5;
static_assert(kAnalogConfigSize + kTableCount * kTableSize == kWaveformSize,
              "Unexpected SSD2683 waveform layout");
static_assert(kRecordsPerTable * kRecordSize == kTableSize,
              "Unexpected SSD2683 table layout");

// Vendor gray-family power, VCOM, PLL and common/border tables stay fixed.
// Offline candidate recipes and retained checks live in tools/display-calibration.
constexpr uint32_t Fnv1a32(
        const std::array<uint8_t, kWaveformSize>& waveform) {
    uint32_t hash = 2166136261u;
    for (uint8_t value : waveform) {
        hash ^= value;
        hash *= 16777619u;
    }
    return hash;
}

inline constexpr std::array<uint8_t, kWaveformSize> kVendorGray4Waveform = {{
    0x00, 0x14, 0x78, 0x78, 0x14, 0x85, 0x08, 0xEF, 0xEF, 0xEF, 0xAF, 0x2F, 0xFF, 0xEF, 0xAF, 0xFF,
    0xEF, 0xEF, 0xEF, 0xEF, 0xEF, 0x3F, 0x7F, 0xFF, 0xEF, 0x7F, 0x3F, 0xFF, 0xEF, 0xEF, 0xEF, 0xEF,
    0xFF, 0xEF, 0xFF, 0xEF, 0xEF, 0x7D, 0x7D, 0xEF, 0xEF, 0xEF, 0xEF, 0xFF, 0xEF, 0xFF, 0xEF, 0xEF,
    0xEF, 0xFF, 0xEF, 0xEF, 0xEF, 0xEF, 0x7F, 0x7F, 0xFF, 0xEF, 0xEF, 0xFF, 0xFF, 0xEF, 0xEF, 0xEF,
    0xEF, 0x7F, 0x7F, 0xFF, 0xEF, 0x6F, 0xEF, 0xFF, 0xEF, 0xEF, 0xEF, 0xEF, 0xEF, 0xEF, 0xFF, 0xEF,
    0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xEF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
    0xDE, 0xFF, 0xAF, 0x2F, 0xFF, 0xEF, 0xAF, 0xFF, 0xEF, 0xEF, 0xEF, 0xD7, 0xD7, 0x3F, 0x7F, 0xFF,
    0xEF, 0x7F, 0x3F, 0xFF, 0xEF, 0xEF, 0xF7, 0xB7, 0xFF, 0xEF, 0xFF, 0xEF, 0xEF, 0x7D, 0x7D, 0xEF,
    0xEF, 0xFE, 0xFA, 0xFF, 0xEF, 0xFF, 0xEF, 0xEF, 0xEF, 0xFF, 0xEF, 0xEF, 0xFA, 0xFB, 0x7F, 0x7F,
    0xFF, 0xEF, 0xEF, 0xFF, 0xFF, 0xEF, 0xEF, 0xFB, 0xFB, 0x7F, 0x7F, 0xFF, 0xEF, 0x6F, 0xEF, 0xFF,
    0xEF, 0xEF, 0xFA, 0xFF, 0xEF, 0xEF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xDE, 0xFB, 0xAF, 0x2F, 0xFF, 0xEF, 0xAF, 0xFF,
    0xEF, 0xEF, 0xEF, 0xD7, 0xD7, 0x3F, 0x7F, 0xFF, 0xEF, 0x7F, 0x3F, 0xFF, 0xEF, 0xEF, 0xF7, 0xFB,
    0xFF, 0xEF, 0xFF, 0xEF, 0xEF, 0x7D, 0x7D, 0xEF, 0xEF, 0xFE, 0xFA, 0xFF, 0xEF, 0xFF, 0xEF, 0xEF,
    0xEF, 0xFF, 0xEF, 0xEF, 0xDE, 0xFB, 0x7F, 0x7F, 0xFF, 0xEF, 0xEF, 0xFF, 0xFF, 0xEF, 0xEF, 0xFA,
    0xFA, 0x7F, 0x7F, 0xFF, 0xEF, 0x6F, 0xEF, 0xFF, 0xEF, 0xEF, 0xD7, 0xFF, 0xEF, 0xEF, 0xFF, 0xEF,
    0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
    0xDE, 0xFF, 0xAF, 0x2F, 0xFF, 0xEF, 0xAF, 0xFF, 0xEF, 0xEF, 0xEF, 0xFE, 0xF7, 0x3F, 0x7F, 0xFF,
    0xEF, 0x7F, 0x3F, 0xFF, 0xEF, 0xEF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xEF, 0xEF, 0x7D, 0x7D, 0xEF,
    0xEF, 0xFE, 0xFE, 0xFF, 0xEF, 0xFF, 0xEF, 0xEF, 0xEF, 0xFF, 0xEF, 0xEF, 0xFB, 0xDF, 0x7F, 0x7F,
    0xFF, 0xEF, 0xEF, 0xFF, 0xFF, 0xEF, 0xEF, 0xFB, 0xDF, 0x7F, 0x7F, 0xFF, 0xEF, 0xEF, 0x6F, 0xFF,
    0xEF, 0xEF, 0xDF, 0xFF, 0xEF, 0xEF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xDE, 0xFB, 0xAF, 0x2F, 0xFF, 0xEF, 0xAF, 0xFF,
    0xEF, 0xEF, 0xEF, 0xFE, 0xFE, 0x3F, 0x7F, 0xFF, 0xEF, 0x7F, 0x3F, 0xFF, 0xEF, 0xEF, 0xFE, 0xFB,
    0xFF, 0xEF, 0xFF, 0xEF, 0xEF, 0x7D, 0x7D, 0xEF, 0xEF, 0xFE, 0xD7, 0xFF, 0xEF, 0xFF, 0xEF, 0xEF,
    0xEF, 0xFF, 0xEF, 0xEF, 0xD7, 0xDF, 0x7F, 0x7F, 0xFF, 0xEF, 0xEF, 0xFF, 0xFF, 0xEF, 0xEF, 0xD7,
    0xD7, 0x7F, 0x7F, 0xFF, 0xEF, 0x6F, 0xEF, 0xFF, 0xEF, 0xEF, 0xD7, 0xFF, 0xEF, 0xEF, 0xFF, 0xEF,
    0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
    0xFF, 0xFF, 0xAF, 0x2F, 0xFF, 0xEF, 0xAF, 0xFF, 0xEF, 0xEF, 0xEF, 0xFF, 0xFF, 0x3F, 0x7F, 0xFF,
    0xEF, 0x7F, 0x3F, 0xFF, 0xEF, 0xEF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xEF, 0xEF, 0x7D, 0x7D, 0xEF,
    0xEF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xEF, 0xEF, 0xEF, 0xFF, 0xEF, 0xEF, 0xFF, 0xFF, 0x7F, 0x7F,
    0xFF, 0xEF, 0xEF, 0xFF, 0xFF, 0xEF, 0xEF, 0xFF, 0xFF, 0x7F, 0x7F, 0xFF, 0xEF, 0x6F, 0xEF, 0xFF,
    0xEF, 0xEF, 0xFF, 0xFF, 0xEF, 0xEF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
}};

static_assert(Fnv1a32(kVendorGray4Waveform) == 0x54F54E58u,
              "SSD2683 vendor four-gray waveform changed");

inline constexpr std::array<note4_epd_gray_level_t, 16> kDefaultLevels = {{{1, 1, 0x00, 0},
                                                                           {3, 1, 0x30, 56},
                                                                           {2, 3, 0x02, 134},
                                                                           {3, 1, 0x04, 204},
                                                                           {3, 1, 0x10, 225},
                                                                           {3, 4, 0x05, 359},
                                                                           {3, 4, 0x04, 394},
                                                                           {3, 4, 0x01, 465},
                                                                           {3, 4, 0x0C, 563},
                                                                           {2, 3, 0x20, 585},
                                                                           {3, 4, 0x44, 690},
                                                                           {3, 2, 0x44, 761},
                                                                           {3, 4, 0x40, 789},
                                                                           {3, 4, 0x14, 866},
                                                                           {3, 4, 0x10, 930},
                                                                           {5, 5, 0x00, 1000}}};

// Keep numeric paint order and the OTP-white base. Holding and phase order
// affect optical output; neither is an editable calibration parameter.
inline std::array<uint8_t, kWaveformSize>
MakeGray16Waveform(const note4_epd_calibration_t& calibration, size_t pass) {
    auto waveform = kVendorGray4Waveform;
    for (size_t code = 0; code < 4; ++code) {
        const note4_epd_gray_level_t hold{5, 5, 0, 1000};
        const auto& target = code == 0 ? hold : calibration.levels[pass * 3 + code - 1];
        for (size_t record = 0; record < kRecordsPerTable; ++record) {
            const size_t table = (target.alternate_mask & (1u << record)) ? target.alternate_table
                                                                          : target.base_table;
            const size_t source = kAnalogConfigSize + table * kTableSize + record * kRecordSize;
            const size_t destination =
                kAnalogConfigSize + (code + 1) * kTableSize + record * kRecordSize;
            // Copy all eleven bytes: drive symbols AND timing are functional.
            for (size_t byte = 0; byte < kRecordSize; ++byte)
                waveform[destination + byte] = kVendorGray4Waveform[source + byte];
        }
    }
    return waveform;
}

constexpr uint8_t CodeForLevel(size_t pass, uint8_t level) {
    return level < 15 && level / 3 == pass ? static_cast<uint8_t>(level % 3 + 1) : 0;
}

// 1,280 bytes in flash; no per-pixel search or refresh-time allocation.
// Each packed source pair becomes four native bits; two pairs form one byte.
constexpr auto MakePackedCodes() {
    std::array<std::array<uint8_t, 256>, kVendorGray16RenderPassCount> result{};
    for (size_t pass = 0; pass < result.size(); ++pass)
        for (size_t pair = 0; pair < 256; ++pair)
            result[pass][pair] = static_cast<uint8_t>((CodeForLevel(pass, pair >> 4) << 2) |
                                                      CodeForLevel(pass, pair & 15));
    return result;
}
inline constexpr auto kPackedCodes = MakePackedCodes();

}  // namespace ssd2683_waveform
#endif // SSD2683_WAVEFORM_H_
